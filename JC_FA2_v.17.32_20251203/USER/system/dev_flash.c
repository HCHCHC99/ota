#include "dev_flash.h"
#include "string.h"
#include "dev_timer0.h"

// 外部声明
extern volatile uint32_t flash_test_result;

// 通道管理
static FlashChannel_t s_flashChannels[MAX_FLASH_DEVICES] = {0};
static uint8_t s_numFlashDevices = 0;

// 默认 Flash 句柄
FlashHandle_t flash_default = NULL;
FlashHandle_t flash_config = NULL;
FlashHandle_t flash_data = NULL;

// Flash 操作集实例
static flash_ops_t hc32_flash_ops = {
    .erase_sector = HC32FLASH_EraseSector,
    .write_word_no_check = HC32FLASH_WritedWord_NoCheck,
    .write_word_check = HC32FLASH_WritedWord_Check,
    .read_word = HC32FLASH_ReaddWord
};

/**
 * @brief 获取扇区索引
 */
static uint16_t Flash_GetSectorIndex(FlashChannel_t* channel, uint32_t address)
{
    if (!channel || address < channel->base_address) {
        return 0xFFFF;
    }
    
    uint32_t offset = address - channel->base_address;
    return offset / channel->sector_size;
}

/**
 * @brief 记录操作历史 - 修改为指针方案
 */
static void Flash_RecordOperation(FlashChannel_t* channel, FlashCommand_t operation, 
                                 uint32_t address, uint32_t data, HC32FLASH_STATUS status)
{
    if (!channel) return;

    
    // 计算新记录的位置（环形缓冲区）
    uint8_t new_index = channel->operation_total % FLASH_OPERATION_HISTORY_SIZE;
    channel->operation_new_index = new_index;
    // 存储新记录
    channel->operation_history[new_index] = (FlashOperationRecord_t){
        .operation_type = operation,
        .address = address,
        .data = data,
        .status = status,
        .sequence_number = channel->operation_total
    };
    
    // 更新最新记录指针
    channel->latest_operation = &channel->operation_history[new_index];
    
    channel->operation_total++;
    // 更新有效记录计数
    if (channel->history_count < FLASH_OPERATION_HISTORY_SIZE) {
        channel->history_count++;
    }
}

/**
 * @brief 更新统计信息
 */
static void Flash_UpdateStatistics(FlashChannel_t* channel, FlashCommand_t operation, HC32FLASH_STATUS status)
{
    if (!channel) return;
    
    channel->statistics.total_operations++;
    
    switch (operation) {
        case CMD_FLASH_ERASE_SECTOR:
            channel->statistics.erase_count++;
            // 更新扇区擦除计数
            if (channel->lifetime.wear_leveling_enabled) {
                uint16_t sector_index = Flash_GetSectorIndex(channel, channel->last_address);
                if (sector_index < channel->lifetime.sector_count) {
                    channel->lifetime.sector_erase_counts[sector_index]++;
                }
            }
            break;
        case CMD_FLASH_WRITE_WORD_NOCHECK:
        case CMD_FLASH_WRITE_WORD_CHECK:
            channel->statistics.write_count++;
            break;
        case CMD_FLASH_READ_WORD:
            channel->statistics.read_count++;
            break;
        default:
            // 其他命令不统计
            break;
    }
    
    if (status != HC32FLASH_OK) {
        channel->statistics.error_count++;
        channel->statistics.consecutive_errors++;
    } else {
        channel->statistics.consecutive_errors = 0;
    }
}

/**
 * @brief 初始化所有 Flash 设备通道
 */
en_result_t Flash_InitAllDevices(void)
{
    memset(s_flashChannels, 0, sizeof(s_flashChannels));
    s_numFlashDevices = 0;
    flash_default = NULL;
    flash_config = NULL;
    flash_data = NULL;
    return Ok;
}

/**
 * @brief 创建 Flash 设备句柄
 */
FlashHandle_t Flash_CreateDevice(uint32_t base_address, uint32_t sector_size, 
                                 uint32_t total_size)
{
    if (s_numFlashDevices >= MAX_FLASH_DEVICES) {
        return NULL;
    }
    
    FlashChannel_t* channel = &s_flashChannels[s_numFlashDevices];
    
    // 初始化硬件配置
    channel->base_address = base_address;
    channel->sector_size = sector_size;
    channel->total_size = total_size;
    
    // 初始化操作集
    channel->ops = hc32_flash_ops;
    
    // 初始化状态
    channel->last_operation = CMD_FLASH_NONE;
    channel->last_address = 0;
    channel->last_data = 0;
    channel->last_status = HC32FLASH_OK;
    channel->initialized = 0;
    
    // 初始化统计信息
    memset(&channel->statistics, 0, sizeof(FlashStatistics_t));
    
    // 初始化操作历史 - 修改为指针方案
    memset(channel->operation_history, 0, sizeof(channel->operation_history));
    channel->latest_operation = NULL;
    channel->history_count = 0;
    channel->operation_new_index = 0;
    channel->operation_total = 0;
    

    // 初始化操作历史记录类型
    for(int i = 0; i < FLASH_OPERATION_HISTORY_SIZE; i++) {
        channel->operation_history[i].operation_type = CMD_FLASH_NONE;
    }

    // 初始化寿命管理
    channel->lifetime.max_erase_cycles = 10000;
    channel->lifetime.warning_threshold = 8000;
    channel->lifetime.wear_leveling_enabled = 0;
    memset(channel->lifetime.sector_erase_counts, 0, sizeof(channel->lifetime.sector_erase_counts));
    channel->lifetime.sector_count = (total_size / sector_size) > MAX_FLASH_SECTORS ? 
                                   MAX_FLASH_SECTORS : (total_size / sector_size);
    
    s_numFlashDevices++;
    return (FlashHandle_t)channel;
}

/**
 * @brief 销毁 Flash 设备句柄
 */
void Flash_DestroyDevice(FlashHandle_t handle)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (channel) {
        // 重置通道状态
        memset(channel, 0, sizeof(FlashChannel_t));
        s_numFlashDevices--;
    }
}

/**
 * @brief 检查地址是否在设备有效范围内
 */
static en_result_t Flash_CheckAddressRange(FlashChannel_t* channel, uint32_t address)
{
    if (!channel) {
        return ErrorInvalidParameter;
    }
    
    if (address < channel->base_address || 
        address >= (channel->base_address + channel->total_size)) {
        return ErrorInvalidParameter;
    }
    
    return Ok;
}

/**
 * @brief 根据设备句柄查找对应的设备ID
 */
static uint8_t Flash_FindDeviceId(FlashHandle_t handle)
{
    for (uint8_t i = 0; i < MAX_DEVICES; i++) {
        DeviceNode_t* device = DeviceManager_GetDevice(i);
        if (device && device->used && device->private_data == handle) {
            return i;
        }
    }
    return 0xFF;
}

/**
 * @brief Flash 设备读取函数
 */
en_result_t Flash_DeviceRead(void* handle, void* data, uint32_t size)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    FlashDeviceData_t* read_data = (FlashDeviceData_t*)data;
    
    if (!channel || !read_data || size < sizeof(FlashDeviceData_t)) {
        return ErrorInvalidParameter;
    }
    
    // 从通道结构复制状态信息到输出缓冲区
    read_data->last_operation = channel->last_operation;
    read_data->last_address = channel->last_address;
    read_data->last_data = channel->last_data;
    read_data->last_status = channel->last_status;
    read_data->config.base_address = channel->base_address;
    read_data->config.sector_size = channel->sector_size;
    read_data->config.total_size = channel->total_size;
    
    // 复制统计信息
    read_data->statistics = channel->statistics;
    
    return Ok;
}

/**
 * @brief Flash 设备写入函数
 */
en_result_t Flash_DeviceWrite(void* handle, const void* data, uint32_t size)
{
    return ErrorInvalidParameter;
}

/**
 * @brief Flash 设备初始化函数
 */
en_result_t Flash_DeviceInit(void* handle)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (!channel) {
        return ErrorInvalidParameter;
    }
    
    // 执行 Flash 硬件初始化
    channel->initialized = 1;
    channel->last_status = HC32FLASH_OK;
    


    return Ok;
}

/**
 * @brief Flash 设备控制函数
 */
en_result_t Flash_DeviceControl(void* handle, DeviceCommandData_t* cmd)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (!channel || !cmd || !channel->initialized) {
        return ErrorInvalidParameter;
    }

    // 根据命令类型执行相应的 Flash 操作
    switch ((FlashCommand_t)cmd->cmd) {
        case CMD_FLASH_ERASE_SECTOR: {
            if (cmd->params && cmd->param_size == sizeof(FlashEraseParams_t)) {
                FlashEraseParams_t* params = (FlashEraseParams_t*)cmd->params;
                channel->last_operation = CMD_FLASH_ERASE_SECTOR;
                channel->last_address = params->address;
                
                if ((params->address & 0x3) != 0) {
                    channel->last_status = HC32FLASH_PGAERR;
                    Flash_RecordOperation(channel, (FlashCommand_t)cmd->cmd, params->address, 0, HC32FLASH_PGAERR);
                    Flash_UpdateStatistics(channel, (FlashCommand_t)cmd->cmd, HC32FLASH_PGAERR);
                    return ErrorInvalidParameter;
                }
                
                if (Flash_CheckAddressRange(channel, params->address) != Ok) {
                    channel->last_status = HC32FLASH_PGAERR;
                    Flash_RecordOperation(channel, (FlashCommand_t)cmd->cmd, params->address, 0, HC32FLASH_PGAERR);
                    Flash_UpdateStatistics(channel, (FlashCommand_t)cmd->cmd, HC32FLASH_PGAERR);
                    return ErrorInvalidParameter;
                }
                
                HC32FLASH_STATUS status = channel->ops.erase_sector(params->address);
                channel->last_status = status;
                
                Flash_RecordOperation(channel, (FlashCommand_t)cmd->cmd, params->address, 0, status);
                Flash_UpdateStatistics(channel, (FlashCommand_t)cmd->cmd, status);
                
                return (status == HC32FLASH_OK) ? Ok : Error;
            }
            break;
        }
        
        case CMD_FLASH_WRITE_WORD_NOCHECK: {
            if (cmd->params && cmd->param_size == sizeof(FlashWriteParams_t)) {
                FlashWriteParams_t* params = (FlashWriteParams_t*)cmd->params;
                channel->last_operation = CMD_FLASH_WRITE_WORD_NOCHECK;
                channel->last_address = params->address;
                channel->last_data = params->data;
                
                if ((params->address & 0x3) != 0) {
                    channel->last_status = HC32FLASH_PGAERR;
                    Flash_RecordOperation(channel, (FlashCommand_t)cmd->cmd, params->address, params->data, HC32FLASH_PGAERR);
                    Flash_UpdateStatistics(channel, (FlashCommand_t)cmd->cmd, HC32FLASH_PGAERR);
                    return ErrorInvalidParameter;
                }
                
                if (Flash_CheckAddressRange(channel, params->address) != Ok) {
                    channel->last_status = HC32FLASH_PGAERR;
                    Flash_RecordOperation(channel, (FlashCommand_t)cmd->cmd, params->address, params->data, HC32FLASH_PGAERR);
                    Flash_UpdateStatistics(channel, (FlashCommand_t)cmd->cmd, HC32FLASH_PGAERR);
                    return ErrorInvalidParameter;
                }
                
                HC32FLASH_STATUS status = channel->ops.write_word_no_check(params->address, params->data);
                channel->last_status = status;
                params->result = status;
                
                Flash_RecordOperation(channel, (FlashCommand_t)cmd->cmd, params->address, params->data, status);
                Flash_UpdateStatistics(channel, (FlashCommand_t)cmd->cmd, status);
                
                return (status == HC32FLASH_OK) ? Ok : Error;
            }
            break;
        }
        
        case CMD_FLASH_WRITE_WORD_CHECK: {
            if (cmd->params && cmd->param_size == sizeof(FlashWriteParams_t)) {
                FlashWriteParams_t* params = (FlashWriteParams_t*)cmd->params;
                channel->last_operation = CMD_FLASH_WRITE_WORD_CHECK;
                channel->last_address = params->address;
                channel->last_data = params->data;
                
                if ((params->address & 0x3) != 0) {
                    channel->last_status = HC32FLASH_PGAERR;
                    Flash_RecordOperation(channel, (FlashCommand_t)cmd->cmd, params->address, params->data, HC32FLASH_PGAERR);
                    Flash_UpdateStatistics(channel, (FlashCommand_t)cmd->cmd, HC32FLASH_PGAERR);
                    return ErrorInvalidParameter;
                }
                
                if (Flash_CheckAddressRange(channel, params->address) != Ok) {
                    channel->last_status = HC32FLASH_PGAERR;
                    Flash_RecordOperation(channel, (FlashCommand_t)cmd->cmd, params->address, params->data, HC32FLASH_PGAERR);
                    Flash_UpdateStatistics(channel, (FlashCommand_t)cmd->cmd, HC32FLASH_PGAERR);
                    return ErrorInvalidParameter;
                }
                
                HC32FLASH_STATUS status = channel->ops.write_word_check(params->address, params->data);
                channel->last_status = status;
                params->result = status;
                
                Flash_RecordOperation(channel, (FlashCommand_t)cmd->cmd, params->address, params->data, status);
                Flash_UpdateStatistics(channel, (FlashCommand_t)cmd->cmd, status);
                
                return (status == HC32FLASH_OK) ? Ok : Error;
            }
            break;
        }
        
        case CMD_FLASH_READ_WORD: {
            if (cmd->params && cmd->param_size == sizeof(FlashReadParams_t)) {
                FlashReadParams_t* params = (FlashReadParams_t*)cmd->params;
                channel->last_operation = CMD_FLASH_READ_WORD;
                channel->last_address = params->address;
                
                if ((params->address & 0x3) != 0) {
                    Flash_RecordOperation(channel, (FlashCommand_t)cmd->cmd, params->address, 0, HC32FLASH_PGAERR);
                    Flash_UpdateStatistics(channel, (FlashCommand_t)cmd->cmd, HC32FLASH_PGAERR);
                    return ErrorInvalidParameter;
                }
                
                if (Flash_CheckAddressRange(channel, params->address) != Ok) {
                    Flash_RecordOperation(channel, (FlashCommand_t)cmd->cmd, params->address, 0, HC32FLASH_PGAERR);
                    Flash_UpdateStatistics(channel, (FlashCommand_t)cmd->cmd, HC32FLASH_PGAERR);
                    return ErrorInvalidParameter;
                }
                
                params->data = channel->ops.read_word(params->address);
                channel->last_data = params->data;
                channel->last_status = HC32FLASH_OK;
                
                Flash_RecordOperation(channel, (FlashCommand_t)cmd->cmd, params->address, params->data, HC32FLASH_OK);
                Flash_UpdateStatistics(channel, (FlashCommand_t)cmd->cmd, HC32FLASH_OK);
                
                return Ok;
            }
            break;
        }
        
        case CMD_FLASH_GET_STATISTICS: {
            if (cmd->params && cmd->param_size == sizeof(FlashStatistics_t)) {
                FlashStatistics_t* stats = (FlashStatistics_t*)cmd->params;
                *stats = channel->statistics;
                return Ok;
            }
            break;
        }
        
        case CMD_FLASH_GET_OPERATION_HISTORY: {
            if (cmd->params && cmd->param_size >= sizeof(FlashOperationRecord_t) * FLASH_OPERATION_HISTORY_SIZE) {
                FlashOperationRecord_t* history = (FlashOperationRecord_t*)cmd->params;
                
                // 按时间顺序复制历史记录（最新的在前）
                uint8_t copied_count = 0;
                if (channel->latest_operation) {
                    // 从最新记录开始向前遍历
                    uint32_t current_seq = channel->latest_operation->sequence_number;
                    
                    for (uint8_t i = 0; i < channel->history_count && i < FLASH_OPERATION_HISTORY_SIZE; i++) {
                        uint8_t index = current_seq % FLASH_OPERATION_HISTORY_SIZE;
                        if (channel->operation_history[index].sequence_number != 0) {
                            history[i] = channel->operation_history[index];
                            copied_count++;
                        }
                        
                        if (current_seq == 0) break;
                        current_seq--;
                    }
                }
                
                // 这里应该返回复制的记录数量，但cmd结构中没有count参数
                // 可以通过其他方式返回，或者保持原有行为
                return Ok;
            }
            break;
        }
        
        case CMD_FLASH_RESET_STATISTICS: {
            memset(&channel->statistics, 0, sizeof(FlashStatistics_t));
            return Ok;
        }
        
        case CMD_FLASH_GET_LIFETIME_INFO: {
            if (cmd->params && cmd->param_size == sizeof(FlashLifetimeInfo_t)) {
                FlashLifetimeInfo_t* info = (FlashLifetimeInfo_t*)cmd->params;
                
                info->max_erase_cycles = channel->lifetime.max_erase_cycles;
                info->warning_threshold = channel->lifetime.warning_threshold;
                info->wear_leveling_supported = channel->lifetime.wear_leveling_enabled;
                
                // 计算当前最大/最小擦除次数
                info->current_max_erase_count = 0;
                info->current_min_erase_count = 0xFFFFFFFF;
                
                for (uint16_t i = 0; i < channel->lifetime.sector_count; i++) {
                    if (channel->lifetime.sector_erase_counts[i] > info->current_max_erase_count) {
                        info->current_max_erase_count = channel->lifetime.sector_erase_counts[i];
                    }
                    if (channel->lifetime.sector_erase_counts[i] < info->current_min_erase_count) {
                        info->current_min_erase_count = channel->lifetime.sector_erase_counts[i];
                    }
                }
                
                // 如果所有扇区计数为0，设置最小值为0 
                if (info->current_min_erase_count == 0xFFFFFFFF) {
                    info->current_min_erase_count = 0;
                }
                
                // 计算健康状态
                if (info->max_erase_cycles > 0) {
                    uint32_t wear_percentage = (info->current_max_erase_count * 100) / info->max_erase_cycles;
                    info->health_status = (wear_percentage >= 100) ? 0 : (100 - wear_percentage);
                } else {
                    info->health_status = 100;
                }
                
                          return Ok;
            }
            break;
        }
        
        case CMD_FLASH_TEST: {
            if (cmd->params && cmd->param_size == sizeof(FlashEraseParams_t)) {
                FlashEraseParams_t* params = (FlashEraseParams_t*)cmd->params;
                channel->last_operation = CMD_FLASH_TEST;
                channel->last_address = params->address;
                
                if (Flash_CheckAddressRange(channel, params->address) != Ok) {
                    return ErrorInvalidParameter;
                }
                
                flash_test_example();
                channel->last_status = HC32FLASH_OK;
                
                Flash_RecordOperation(channel, (FlashCommand_t)cmd->cmd, params->address, 0, HC32FLASH_OK);
                Flash_UpdateStatistics(channel, (FlashCommand_t)cmd->cmd, HC32FLASH_OK);
                
                return Ok;
            }
            break;
        }
            
        default:
            switch ((FlashCommand_t)cmd->cmd) {
                case CMD_DEVICE_ENABLE:
                    return Ok;
                case CMD_DEVICE_DISABLE:
                    return Ok;
                default:
                    break;
            }
            break;
    }
    
    return ErrorInvalidParameter;
}

/**
 * @brief Flash 设备更新函数
 */
en_result_t Flash_DeviceUpdate(void* handle)
{
    return Ok;
}

/**
 * @brief 应用层 Flash 扇区擦除函数
 */
en_result_t Flash_EraseSector(FlashHandle_t handle, uint32_t address)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (!channel || !channel->initialized) {
        return ErrorInvalidParameter;
    }
    
    // 计算绝对地址
    uint32_t absolute_address = address;
    if (address < channel->base_address) {
        absolute_address = channel->base_address + address;
    }
    
    // 检查地址范围
    if (Flash_CheckAddressRange(channel, absolute_address) != Ok) {
        return ErrorInvalidParameter;
    }
    
    DeviceCommandData_t cmd;
    FlashEraseParams_t params;
    
    params.address = absolute_address;
    cmd.cmd = CMD_FLASH_ERASE_SECTOR;
    cmd.device_id = Flash_FindDeviceId(handle);
    cmd.params = &params;
    cmd.param_size = sizeof(FlashEraseParams_t);
    
    return Flash_DeviceControl(handle, &cmd);
}

/**
 * @brief 应用层无校验 Flash 写入函数
 */
en_result_t Flash_WriteWordNoCheck(FlashHandle_t handle, uint32_t address, uint32_t data)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (!channel || !channel->initialized) {
        return ErrorInvalidParameter;
    }
    
    // 计算绝对地址
    uint32_t absolute_address = address;
    if (address < channel->base_address) {
        absolute_address = channel->base_address + address;
    }
    
    // 检查地址范围
    if (Flash_CheckAddressRange(channel, absolute_address) != Ok) {
        return ErrorInvalidParameter;
    }
    
    DeviceCommandData_t cmd;
    FlashWriteParams_t params;
    
    params.address = absolute_address;
    params.data = data;
    params.result = 0;
    
    cmd.cmd = CMD_FLASH_WRITE_WORD_NOCHECK;
    cmd.device_id = Flash_FindDeviceId(handle);
    cmd.params = &params;
    cmd.param_size = sizeof(FlashWriteParams_t);
    
    return Flash_DeviceControl(handle, &cmd);
}

/**
 * @brief 应用层带校验 Flash 写入函数
 */
en_result_t Flash_WriteWordCheck(FlashHandle_t handle, uint32_t address, uint32_t data)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (!channel || !channel->initialized) {
        return ErrorInvalidParameter;
    }
    
    // 计算绝对地址
    uint32_t absolute_address = address;
    if (address < channel->base_address) {
        absolute_address = channel->base_address + address;
    }
    
    // 检查地址范围
    if (Flash_CheckAddressRange(channel, absolute_address) != Ok) {
        return ErrorInvalidParameter;
    }
    
    DeviceCommandData_t cmd;
    FlashWriteParams_t params;
    
    params.address = absolute_address;
    params.data = data;
    params.result = 0;
    
    cmd.cmd = CMD_FLASH_WRITE_WORD_CHECK;
    cmd.device_id = Flash_FindDeviceId(handle);
    cmd.params = &params;
    cmd.param_size = sizeof(FlashWriteParams_t);
    
    return Flash_DeviceControl(handle, &cmd);
}

/**
 * @brief 应用层 Flash 读取函数
 */
uint32_t Flash_ReadWord(FlashHandle_t handle, uint32_t address)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (!channel || !channel->initialized) {
        return 0xFFFFFFFF;
    }
    
    // 计算绝对地址
    uint32_t absolute_address = address;
    if (address < channel->base_address) {
        absolute_address = channel->base_address + address;
    }
    
    // 检查地址范围
    if (Flash_CheckAddressRange(channel, absolute_address) != Ok) {
        return 0xFFFFFFFF;
    }
    
    DeviceCommandData_t cmd;
    FlashReadParams_t params;
    
    params.address = absolute_address;
    params.data = 0;
    
    cmd.cmd = CMD_FLASH_READ_WORD;
    cmd.device_id = Flash_FindDeviceId(handle);
    cmd.params = &params;
    cmd.param_size = sizeof(FlashReadParams_t);
    
    if (Flash_DeviceControl(handle, &cmd) == Ok) {
        return params.data;
    }
    
    return 0xFFFFFFFF;
}

/**
 * @brief 应用层 Flash 测试函数
 */
en_result_t Flash_RunTest(FlashHandle_t handle, uint32_t address)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (!channel || !channel->initialized) {
        return ErrorInvalidParameter;
    }
    
    // 计算绝对地址
    uint32_t absolute_address = address;
    if (address < channel->base_address) {
        absolute_address = channel->base_address + address;
    }
    
    // 检查地址范围
    if (Flash_CheckAddressRange(channel, absolute_address) != Ok) {
        return ErrorInvalidParameter;
    }
    
    DeviceCommandData_t cmd;
    FlashEraseParams_t params;
    
    params.address = absolute_address;
    cmd.cmd = CMD_FLASH_TEST;
    cmd.device_id = Flash_FindDeviceId(handle);
    cmd.params = &params;
    cmd.param_size = sizeof(FlashEraseParams_t);
    
    return Flash_DeviceControl(handle, &cmd);
}

/**
 * @brief 获取 Flash 设备状态
 */
en_result_t Flash_GetDeviceStatus(FlashHandle_t handle, volatile FlashDeviceData_t* status)
{
    if (!status) {
        return ErrorInvalidParameter;
    }
    
    uint8_t device_id = Flash_FindDeviceId(handle);
    if (device_id == 0xFF) {
        return ErrorInvalidParameter;
    }
    
    return Device_Read(device_id, (void*)status, sizeof(FlashDeviceData_t));
}

/**
 * @brief 获取 Flash 设备配置信息
 */
en_result_t Flash_GetDeviceConfig(FlashHandle_t handle, FlashDeviceConfig_t* config)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (!channel || !config) {
        return ErrorInvalidParameter;
    }
    
    config->base_address = channel->base_address;
    config->sector_size = channel->sector_size;
    config->total_size = channel->total_size;
    
    return Ok;
}

/**
 * @brief 设置 Flash 设备配置信息
 */
en_result_t Flash_SetDeviceConfig(FlashHandle_t handle, const FlashDeviceConfig_t* config)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (!channel || !config || channel->initialized) {
        return ErrorInvalidParameter;
    }
    
    channel->base_address = config->base_address;
    channel->sector_size = config->sector_size;
    channel->total_size = config->total_size;
    
    return Ok;
}

/**
 * @brief 新增：获取统计信息
 */
en_result_t Flash_GetStatistics(FlashHandle_t handle, FlashStatistics_t* stats)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (!channel || !stats) {
        return ErrorInvalidParameter;
    }
    
    DeviceCommandData_t cmd;
    cmd.cmd = CMD_FLASH_GET_STATISTICS;
    cmd.device_id = Flash_FindDeviceId(handle);
    cmd.params = stats;
    cmd.param_size = sizeof(FlashStatistics_t);
    
    return Flash_DeviceControl(handle, &cmd);
}



/**
 * @brief 新增：重置统计信息
 */
en_result_t Flash_ResetStatistics(FlashHandle_t handle)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (!channel) {
        return ErrorInvalidParameter;
    }
    
    DeviceCommandData_t cmd;
    cmd.cmd = CMD_FLASH_RESET_STATISTICS;
    cmd.device_id = Flash_FindDeviceId(handle);
    cmd.params = NULL;
    cmd.param_size = 0;
    
    return Flash_DeviceControl(handle, &cmd);
}

/**
 * @brief 新增：获取寿命信息
 */
en_result_t Flash_GetLifetimeInfo(FlashHandle_t handle, FlashLifetimeInfo_t* info)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (!channel || !info) {
        return ErrorInvalidParameter;
    }
    
    DeviceCommandData_t cmd;
    cmd.cmd = CMD_FLASH_GET_LIFETIME_INFO;
    cmd.device_id = Flash_FindDeviceId(handle);
    cmd.params = info;
    cmd.param_size = sizeof(FlashLifetimeInfo_t);
    
    return Flash_DeviceControl(handle, &cmd);
}

/**
 * @brief 全局初始化函数
 */
en_result_t Flash_Device_Init(void)
{
    Flash_InitAllDevices();
    
    flash_default = Flash_CreateDevice(0x00020000, 0x1000, 0x10000);
    if (!flash_default) {
        return Error;
    }
    
    return REGISTER_FLASH_DEVICE(0, "Flash_Device", flash_default);
}

/**
 * @brief Flash 设备反初始化
 */
en_result_t Flash_Device_Deinit(void)
{
    return DeviceManager_UnregisterDevice(0);
}

/**
 * @brief 新增：获取操作历史（按时间顺序，最新的在前）
 */
en_result_t Flash_GetOperationHistory(FlashHandle_t handle, FlashOperationRecord_t* history, uint8_t* count)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (!channel || !history || !count) {
        return ErrorInvalidParameter;
    }
    
    uint8_t copied_count = 0;
    
    if (channel->latest_operation) {
        // 从最新记录开始向前遍历
        uint32_t current_seq = channel->latest_operation->sequence_number;
        
        for (uint8_t i = 0; i < channel->history_count && i < FLASH_OPERATION_HISTORY_SIZE; i++) {
            uint8_t index = current_seq % FLASH_OPERATION_HISTORY_SIZE;
            if (channel->operation_history[index].sequence_number != 0) {
                history[i] = channel->operation_history[index];
                copied_count++;
            }
            
            if (current_seq == 0) break;
            current_seq--;
        }
    }
    
    *count = copied_count;
    return Ok;
}

/**
 * @brief 新增：获取有效的操作记录数量
 */
uint8_t Flash_GetValidOperationCount(FlashHandle_t handle)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (!channel) return 0;
    
    return channel->history_count;
}

/**
 * @brief 新增：获取最新的操作记录
 */
en_result_t Flash_GetLatestOperation(FlashHandle_t handle, FlashOperationRecord_t* record)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (!channel || !record) {
        return ErrorInvalidParameter;
    }
    
    if (channel->latest_operation) {
        *record = *channel->latest_operation;
        return Ok;
    }
    
    return Error;  // 没有有效记录
}

/**
 * @brief 新增：按索引获取操作记录（0=最新，1=次新，依此类推）
 */
en_result_t Flash_GetOperationByIndex(FlashHandle_t handle, uint8_t index, FlashOperationRecord_t* record)
{
    FlashChannel_t* channel = (FlashChannel_t*)handle;
    if (!channel || !record || index >= channel->history_count) {
        return ErrorInvalidParameter;
    }
    
    if (channel->latest_operation) {
        // 从最新记录开始向前推算
        uint32_t target_seq = channel->latest_operation->sequence_number - index;
        uint8_t target_index = target_seq % FLASH_OPERATION_HISTORY_SIZE;
        
        if (channel->operation_history[target_index].sequence_number == target_seq) {
            *record = channel->operation_history[target_index];
            return Ok;
        }
    }
    
    return Error;
}

/**
 * @brief Flash 设备注册示例
 */
void Flash_Device_Registration(void)
{
    Flash_InitAllDevices();
    
    flash_config = Flash_CreateDevice(0x00020000, 0x1000, 0x4000);
    flash_data = Flash_CreateDevice(0x00024000, 0x1000, 0x4000);
    
    REGISTER_FLASH_DEVICE(10, "Flash_Config", flash_config);
    REGISTER_FLASH_DEVICE(11, "Flash_Data", flash_data);
    
    Device_Init(10);
    Device_Init(11);
}

/**
 * @brief 测试函数：完整的读-擦除-写流程
 */
void Application_Flash_TestSequence(void)
{
    TIMER0_DISABLE;

    DeviceCommandData_t cmd;
    FlashReadParams_t read_params;
    FlashEraseParams_t erase_params;
    FlashWriteParams_t write_params;
    
    // 测试地址
    uint32_t test_address = 0x00020000;
    
    // 步骤1：读取原始数据
    memset(&cmd, 0, sizeof(DeviceCommandData_t));
    memset(&read_params, 0, sizeof(FlashReadParams_t));
    
    read_params.address = test_address;
    cmd.cmd = CMD_FLASH_READ_WORD;
    cmd.device_id = 10;
    cmd.params = &read_params;
    cmd.param_size = sizeof(FlashReadParams_t);
    
    en_result_t result = Device_Control(10, &cmd);
    uint32_t original_data = read_params.data;
    
    // 步骤2：擦除扇区
    memset(&cmd, 0, sizeof(DeviceCommandData_t));
    memset(&erase_params, 0, sizeof(FlashEraseParams_t));
    
    erase_params.address = test_address;
    cmd.cmd = CMD_FLASH_ERASE_SECTOR;
    cmd.device_id = 10;
    cmd.params = &erase_params;
    cmd.param_size = sizeof(FlashEraseParams_t);
    
    result = Device_Control(10, &cmd);
    
    // 步骤3：验证擦除后数据为0xFFFFFFFF
    memset(&cmd, 0, sizeof(DeviceCommandData_t));
    memset(&read_params, 0, sizeof(FlashReadParams_t));
    
    read_params.address = test_address;
    cmd.cmd = CMD_FLASH_READ_WORD;
    cmd.device_id = 10;
    cmd.params = &read_params;
    cmd.param_size = sizeof(FlashReadParams_t);
    
    result = Device_Control(10, &cmd);
    uint32_t erased_data = read_params.data;
    
    // 步骤4：写入测试数据
    memset(&cmd, 0, sizeof(DeviceCommandData_t));
    memset(&write_params, 0, sizeof(FlashWriteParams_t));
    
    write_params.address = test_address;
    write_params.data = 0x12345678;
    cmd.cmd = CMD_FLASH_WRITE_WORD_CHECK;
    cmd.device_id = 10;
    cmd.params = &write_params;
    cmd.param_size = sizeof(FlashWriteParams_t);
    
    result = Device_Control(10, &cmd);
    
    // 步骤5：验证写入的数据
    memset(&cmd, 0, sizeof(DeviceCommandData_t));
    memset(&read_params, 0, sizeof(FlashReadParams_t));
    
    read_params.address = test_address;
    cmd.cmd = CMD_FLASH_READ_WORD;
    cmd.device_id = 10;
    cmd.params = &read_params;
    cmd.param_size = sizeof(FlashReadParams_t);
    
    result = Device_Control(10, &cmd);
    uint32_t final_data = read_params.data;
    
    // 存储测试结果
    volatile uint32_t test_results[4];
    test_results[0] = original_data;
    test_results[1] = erased_data;
    test_results[2] = final_data;
    test_results[3] = (final_data == 0x12345678) ? 0x55555555 : 0xAAAAAAAA;
    TIMER0_ENABLE;
}

/**
 * @brief 数据区测试：多个地址的读写测试
 */
void Application_Flash_DataAreaTest(void)
{
    TIMER0_DISABLE;
    DeviceCommandData_t cmd;
    FlashEraseParams_t erase_params;
    FlashWriteParams_t write_params;
    FlashReadParams_t read_params;
    
    // 先擦除整个数据区扇区
    memset(&cmd, 0, sizeof(DeviceCommandData_t));
    memset(&erase_params, 0, sizeof(FlashEraseParams_t));
    
    erase_params.address = 0x00024000;
    cmd.cmd = CMD_FLASH_ERASE_SECTOR;
    cmd.device_id = 11;
    cmd.params = &erase_params;
    cmd.param_size = sizeof(FlashEraseParams_t);
    
    Device_Control(11, &cmd);
    
    // 写入多个测试数据
    uint32_t test_addresses[] = {0x00024000, 0x00024004, 0x00024008, 0x0002400C};
    uint32_t test_data[] = {0x11111111, 0x22222222, 0x33333333, 0x44444444};
    
    // 写入数据
    for (int i = 0; i < 4; i++) {
        memset(&cmd, 0, sizeof(DeviceCommandData_t));
        memset(&write_params, 0, sizeof(FlashWriteParams_t));
        
        write_params.address = test_addresses[i];
        write_params.data = test_data[i];
        cmd.cmd = CMD_FLASH_WRITE_WORD_CHECK;
        cmd.device_id = 11;
        cmd.params = &write_params;
        cmd.param_size = sizeof(FlashWriteParams_t);
        
        Device_Control(11, &cmd);
    }
    
    // 读取验证
    volatile uint32_t read_back_data[4];
    for (int i = 0; i < 4; i++) {
        memset(&cmd, 0, sizeof(DeviceCommandData_t));
        memset(&read_params, 0, sizeof(FlashReadParams_t));
        
        read_params.address = test_addresses[i];
        cmd.cmd = CMD_FLASH_READ_WORD;
        cmd.device_id = 11;
        cmd.params = &read_params;
        cmd.param_size = sizeof(FlashReadParams_t);
        
        Device_Control(11, &cmd);
        read_back_data[i] = read_params.data;
    }
    TIMER0_ENABLE;
}


