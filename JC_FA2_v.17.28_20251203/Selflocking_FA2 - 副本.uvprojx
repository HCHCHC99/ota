# Keil uVision project Selflocking_FA2 - 副本.uvprojx, settings and files
target Selflocking_FA2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Selflocking_FA2 +hex
  AfterMake: fromelf --bin -o ".\@L.bin" ".\Objects\@L.axf"
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB
  c include: .\driver\inc;.\common;.\USER;.\USER\adapter;.\USER\btn;.\USER\debug;.\USER\MotorControl;.\USER\system;.\USER\CanOpen;.\USER\msg;.\USER\math;.\RTT;.\USER\UDS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  group common
    ./common/: startup_hc32f46x.s system_hc32f46x.c
  group driver
    ./driver/src/: hc32f46x_adc.c hc32f46x_aes.c hc32f46x_can.c hc32f46x_clk.c hc32f46x_cmp.c hc32f46x_crc.c hc32f46x_dcu.c hc32f46x_dmac.c hc32f46x_efm.c hc32f46x_emb.c hc32f46x_event_port.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_hash.c hc32f46x_i2c.c hc32f46x_i2s.c hc32f46x_icg.c hc32f46x_interrupts.c hc32f46x_keyscan.c hc32f46x_mpu.c hc32f46x_ots.c hc32f46x_pwc.c hc32f46x_qspi.c hc32f46x_rmu.c hc32f46x_rtc.c hc32f46x_sdioc.c hc32f46x_spi.c hc32f46x_sram.c hc32f46x_swdt.c hc32f46x_timer0.c hc32f46x_timer4_cnt.c hc32f46x_timer4_emb.c hc32f46x_timer4_oco.c hc32f46x_timer4_pwm.c hc32f46x_timer4_sevt.c hc32f46x_timer6.c hc32f46x_timera.c hc32f46x_trng.c hc32f46x_usart.c hc32f46x_utility.c hc32f46x_wdt.c
  group adapter
    ./USER/adapter/: adc_adapter.c delay_adapter.c flash_adapter.c gpio_adapter.c timer_adapter.c uart_adapter.c can_adapter.c ring_buffer.c adapter_pwm.c
  group motorControl
    ./USER/MotorControl/: mc_cur.c mc_drv.c mc_app.c mc_hall.c mc_pos.c mc_spd.c pid.c
  group btn
    ./USER/btn/: btn.c btn_drv.c
  group system
    ./USER/system/: system.c sys_cfg.c hz_timer.c hall_position.c hardware.c motor_cmd.c power.c sys_main_state.c usart_usb.c hz_nopwm.c module_usart.c motor_adc.c device_manager.c dev_pwm.c canJ1939.c dev_flash.c dev_timer0.c flash_advanced.c hc32f46x_flash.c
  group main
    ./USER/: main.c
  group CanOpen
    ./USER/CanOpen/: co.c co_sdo.c
  group ModbusMsg
    ./USER/msg/: modbus.c queue.c
  group math
    ./USER/math/: crc.c
  group RTT
    ./RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group UDS
    ./USER/UDS/: isotp_transport.c security_access.c uds_diagnostic.c flash_download.c uds_dl_bridge.c
software components: CMSIS:CORE 5.4.0
